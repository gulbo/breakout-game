# Keil uVision project breakout_game.uvprojx, settings and files
target LPC1768BOARD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: breakout_game
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\h_source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Main
    ./c_source/: main.cpp game_elements.cpp
  group Libs
    ./c_source/: Buttons_MCB1700.c GLCD_SPI_LPC1700.c LED_MCB1700.c DAC_LPC1768.c
  group Headers
    ./h_source/: Board_Buttons.h Board_LED.h Font_6x8_h.h Font_16x24_h.h GLCD.h DAC_LPC1768.h
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX5 5.3.0, CMSIS:RTOS2:Keil RTX5 5.3.0, CMSIS Driver:SPI:SPI 2.1.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
